<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F413ZHT6_Proyecto-sys-UV-sensor.ewp</path>
  </project>
  <batchBuild />
</workspace>
